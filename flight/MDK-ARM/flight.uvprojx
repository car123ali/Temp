# Keil uVision project flight.uvprojx, settings and files
target flight (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: flight +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middle/FreeRTOS/include;../Middle/FreeRTOS/portable/RVDS/ARM_CM3;../Tasks;../Interface/Inc;../Common/Inc;../App/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c i2c.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middle/FreeRTOS
    ../Middle/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middle/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../Middle/FreeRTOS/portable/MemMang/: heap_4.c
  group Tasks
    ../Tasks/: fligh_task.c
  group Interface
    ../Interface/Src/: Int_IP5305T.c Int_LED.c Int_Motor.c Int_SI24R1.c Int_MPU6050.c vl53l1_platform.c VL53L1X_api.c VL53L1X_calibration.c Int_VL53L1X.c
  group Common
    ../Common/Src/: Com_temp.c Com_Filter.c Com_IMU.c Com_PID.c
  group App
    ../App/Src/: app_remote_data.c app_motor.c
software components: CMSIS:CORE 4.3.0
